# Keil uVision project Project.uvproj, settings and files
target Project (ARM-ADS)
  device: STM32F439IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Project +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_STM324xG_EVAL,STM32F429_439xx
  c misc: --C99
  c include: ..\CODE;..\..\Project;..\..\FWLIB\inc;..\..\CMSIS;..\..\DRIVER
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../../CMSIS/: system_stm32f4xx.c
    ../../CMSIS/startup/: startup_stm32f4xx.s
  group USER
    ../: main.c stm32f4xx_it.c
  group DRIVER
    ../../DRIVER/: exti.c key.c led.c sys.c
  group FWLIB
    ../../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_exti.c
  group README
    ../../: readme.txt
